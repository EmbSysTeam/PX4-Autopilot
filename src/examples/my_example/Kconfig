## src/examples/my_example/Kconfig
```kconfig
menuconfig EXAMPLES_MY_EXAMPLE
	bool "My example"
	default n
	---help---
		Enable My example app
```
